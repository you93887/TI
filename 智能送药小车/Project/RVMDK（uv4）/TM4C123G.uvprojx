# Keil uVision project TM4C123G.uvprojx, settings and files
target TIVA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PZ Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4C123G +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PZ TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ..\..\Libraries\inc;..\..\Libraries\utils;..\..\Libraries\driverlib;..\..\Hardware;..\..\User;..\..\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Libraries
    ../../Libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Hardware
    ../../Hardware/: LED.c LED.h OLED_Data.c OLED_Data.h OLED.c OLED.h Serial.c Serial.h Timer_user.c Timer_user.h PWM_user.c PWM_user.h ButtonsInterrupt.c ButtonsInterrupt.h ADC_user.c ADC_user.h Motor.c Motor.h PID.c PID.h VOFA.c VOFA.h RedSensor.c RedSensor.h Tof.h Tof.c BLEUART.c BLEUART.h Task.c Task.h Buzzer.c Buzzer.h MPU9050.c MPU9050.h neeprom.h neeprom.c
  group User
    ../../User/: main.c startup_rvmdk.S include.h
    ../../Libraries/utils/: uartstdio.c
  group Doc
    ../../Doc/: readme.txt
  group Drivers
    ../../Drivers/: SystickTime.c SystickTime.h binary.h
software components: CMSIS:CORE 5.0.1
