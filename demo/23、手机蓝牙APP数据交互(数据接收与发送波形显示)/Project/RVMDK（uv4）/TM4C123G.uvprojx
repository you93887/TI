# Keil uVision project TM4C123G.uvprojx, settings and files
target TIVA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PZ Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4C123G +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PZ TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ..\..\Libraries\inc;..\..\Libraries\utils;..\..\Libraries\driverlib;..\..\User;..\..\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Libraries
    ../../Libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group User
    ../../User/: main.c startup_rvmdk.S
    ../../Libraries/utils/: uartstdio.c
  group Drivers
    ../../Drivers/: SystickTime.c OLED.c ssd1306.c WP_DataType.h WP_Math.c WP_ADC.c PPM.h PPM.c
  group Doc
    ../../Doc/: readme.txt
software components: CMSIS:CORE 5.0.1
